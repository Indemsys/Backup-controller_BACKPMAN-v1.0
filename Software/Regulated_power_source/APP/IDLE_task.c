// ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
// 2021-08-27
// 15:36:00
// ~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~~
#include   "App.h"

TX_THREAD                     idle_thread;
#pragma data_alignment=8
uint8_t                       thread_idle_stack[THREAD_IDLE_STACK_SIZE];

/*-------------------------------------------------------------------------------------------------------------
  Фоновая задача.
  Измеряет загруженность процессора
-------------------------------------------------------------------------------------------------------------*/
static void Thread_idle(ULONG initial_input)
{
  uint64_t  t;
  uint64_t  dt;

  for (;;)
  {
    t = Measure_reference_time_interval(REF_TIME_INTERVAL);

    if (t < ref_time)
    {
      dt = 0;
    }
    else
    {
      dt = t - ref_time;
    }
    g_cpu_usage =(1000ull * dt) / ref_time;

    if (request_save_to_NV_mem)
    {
      request_save_to_NV_mem =0;
      Save_Params_to_NV_store();
    }
    //Wdog_refresh();
  }
}


/*-----------------------------------------------------------------------------------------------------


  \param void
-----------------------------------------------------------------------------------------------------*/
void Thread_idle_create(void)
{
  tx_thread_create(&idle_thread, "IDLE", Thread_idle,
    0,
    (void *)thread_idle_stack, // stack_start
    THREAD_IDLE_STACK_SIZE,   // stack_size
    THREAD_IDLE_PRIORITY,     // priority. Numerical priority of thread. Legal values range from 0 through (TX_MAX_PRIORITES-1), where a value of 0 represents the highest priority.
    THREAD_IDLE_PRIORITY,     // preempt_threshold. Highest priority level (0 through (TX_MAX_PRIORITIES-1)) of disabled preemption. Only priorities higher than this level are allowed to preempt this thread. This value must be less than or equal to the specified priority. A value equal to the thread priority disables preemption-threshold.
    TX_NO_TIME_SLICE,
    TX_AUTO_START);
}



