<?xml version="1.0" encoding="ISO-8859-1" standalone="no"?>
<workspace>
    
  <batchBuild>
        
    <batchDefinition>
            
      <name>all</name>
            
      <member>
                
        <project>RTOS_profiling</project>
                
        <configuration>release</configuration>
              
      </member>
            
      <member>
                
        <project>RTOS_profiling</project>
                
        <configuration>debug</configuration>
              
      </member>
          
    </batchDefinition>
        
    <batchDefinition>
            
      <name>release</name>
            
      <member>
                
        <project>RTOS_profiling</project>
                
        <configuration>release</configuration>
              
      </member>
          
    </batchDefinition>
        
    <batchDefinition>
            
      <name>debug</name>
            
      <member>
                
        <project>RTOS_profiling</project>
                
        <configuration>debug</configuration>
              
      </member>
          
    </batchDefinition>
      
  </batchBuild>
    
  <project>
        
    <path>$WS_DIR$/RTOS_profiling.ewp</path>
      
  </project>
  
</workspace>
